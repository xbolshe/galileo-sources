EXTRA_OECONF_append_pn-openssl = "no-asm"
