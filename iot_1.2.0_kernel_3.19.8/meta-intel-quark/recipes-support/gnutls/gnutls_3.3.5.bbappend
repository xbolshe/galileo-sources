EXTRA_OECONF+= " --disable-hardware-acceleration"
