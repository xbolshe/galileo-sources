IMAGE_INSTALL += "native-border-router libcoap"
IMAGE_INSTALL += "radvd"
