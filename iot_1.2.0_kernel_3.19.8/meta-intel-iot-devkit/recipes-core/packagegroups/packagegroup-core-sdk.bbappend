RDEPENDS_packagegroup-core-sdk_remove = "distcc"
